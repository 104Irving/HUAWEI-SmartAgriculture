# Keil uVision project AHT20+BMP280.uvprojx, settings and files
target AHT20+BMP280 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: AHT20+BMP280 +hex
  c flags: OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210B_EVAL
  c include: .\FWlib\inc;.\user;.\CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./user/: main.c bsp_i2c.c ATH20.c BMP280.c
    ./FWlib/SRC/: misc.c
  group StdPeriph_Driver
    ./FWlib/SRC/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group RVMDK
    ./startup/: startup_stm32f10x_hd.s
  group CMSIS
    ./CM3/: core_cm3.c system_stm32f10x.c
software components: CMSIS:CORE 5.1.1
