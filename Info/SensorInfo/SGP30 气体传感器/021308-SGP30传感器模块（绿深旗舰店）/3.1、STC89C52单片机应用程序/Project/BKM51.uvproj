# Keil uVision project BKM51.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: BKM51 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User\SGP30;..\User\Delay;..\User
  group Source Group 1
    ../User/: main.c
    ../User/Delay/: delay.c
    ../User/SGP30/: SGP30.c
