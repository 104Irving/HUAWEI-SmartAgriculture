# Keil uVision project BKM51.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: BKM51 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User\IIC_OLED;..\User\Delay;..\User;..\User\SGP30
  group Source Group 1
    ../User/: main.c
    ../User/Delay/: delay.c
    ../User/SGP30/: SGP30.c
